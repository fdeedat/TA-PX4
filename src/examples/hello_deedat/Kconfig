## src/examples/hello_deedat/Kconfig
```kconfig
menuconfig EXAMPLES_HELLO_DEEDAT
	bool "hello_deedat"
	default n
	---help---
		Enable support for hello_deedat
```
